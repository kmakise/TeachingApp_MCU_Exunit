# Keil uVision project keyboard.uvproj, settings and files
target Amadeus (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Application\inc
  group Application/Main
    ./Application/src/: Main.c KeyApp.c
  group Application/Driver
    ./Application/src/: keyboard.c UartCom.c tim.c
  group Core
    ./: STARTUP.A51
